# Keil uVision project APM32F10x_FreeRTOS.uvprojx, settings and files
target APM32F10x_FreeRTOS_TASK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32F10x_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F103xE,APM32F103_MINI
  c include: ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include;..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../Source/: system_apm32f10x.c
    ./: startup_apm32f103xe.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group Boards
    ../../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c apm32f10x_int.c
  group FREE_RTOS
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
