# Keil uVision project APM32F10x_CMSIS_RTX.uvprojx, settings and files
target APM32F10x_CMSIS_RTX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32F10x_CMSIS_RTX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F103xE,APM32F103_MINI
  c include: ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include;..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Include;..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Source;..\..\..\..\..\..\Libraries\CMSIS\RTOS2\RTX\Include;..\..\RTOS2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../../Source/: apm32f10x_int.c main.c
  group CMSIS
    ../../Source/: system_apm32f10x.c
    ./: startup_apm32f103xe.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group Boards
    ../../../../../../Boards/: Board.c
  group RTOS2
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/ARM/: irq_armv6m.s
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../../../../../Libraries/CMSIS/RTOS2/Source/: os_systick.c
    ../../RTOS2/: RTE_Components.h RTX_Config.c RTX_Config.h
