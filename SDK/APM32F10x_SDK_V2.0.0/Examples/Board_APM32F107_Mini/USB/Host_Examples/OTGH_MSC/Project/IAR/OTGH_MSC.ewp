# IAR project OTGH_MSC.ewp, settings and files
configuration APM32F107 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F107VC Geehy APM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F107xC; APM32F107_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Boards\Board_APM32F107_MINI\inc; ..\..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\MSC\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc; ..\..\Include; ..\..\Fat_Fs; ..\..\..\..\..\..\..\Middlewares\FatFs\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGH_MSC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f107xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Bsp
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32F103_MINI/src/: board_delay.c
  group App/User
    ../../Source/: apm32f10x_int.c fatfs.c main.c
  group App/User/FATFS/App
    ../../../../../../../Middlewares/FatFs/source/: diskio.c
    ../../Fat_Fs/: usbh_diskio.c
  group App/User/USB_HOST/App
    ../../Source/: usb_host_user.c
  group App/User/USB_HOST/Config
    ../../Source/: usbh_board.c
  group CMSIS
    ./: startup_apm32f107xc.s
    ../../Source/: system_apm32f10x.c
  group Libraries/APM32F10x_Std_Driver
    ../../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_eth.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_usb.c apm32f10x_usb_device.c apm32f10x_usb_host.c apm32f10x_wwdt.c
  group Middlewares/FatFs
    ../../../../../../../Middlewares/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/USB_Host_Library
    ../../../../../../../Middlewares/USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Host_Library/Class
    ../../../../../../../Middlewares/USB_Library/Host/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
