# IAR project Template.ewp, settings and files
configuration APM32F105 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F105VC Geehy APM32F105VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F105xC; APM32F107_MINI
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F107 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F107VC Geehy APM32F107VC
  ICCARM.CCDefines: APM32F107xC; APM32F107_MINI
  group Application
    ../../Source/: apm32f10x_int.c main.c
  group Board
    ../../../../../../Boards/: Board.c
  group CMSIS
    ./: startup_apm32f105xc.s startup_apm32f107xc.s
    ../../Source/: system_apm32f10x.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_eth.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_usb.c apm32f10x_usb_device.c apm32f10x_usb_host.c apm32f10x_wwdt.c
