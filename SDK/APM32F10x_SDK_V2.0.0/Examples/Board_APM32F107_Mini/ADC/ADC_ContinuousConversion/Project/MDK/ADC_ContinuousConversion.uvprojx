# Keil uVision project ADC_ContinuousConversion.uvprojx, settings and files
target APM32F105 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F105VC Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC_ContinuousConversion
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F105xC,APM32F107_MINI
  c include: ..\..\Include;..\..\..\..\..\..\Boards;..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f10x.c
    ./: startup_apm32f105xc.s startup_apm32f107xc.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_smc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c apm32f10x_eth.c apm32f10x_usb.c apm32f10x_usb_device.c apm32f10x_usb_host.c
  group Application
    ../../Source/: main.c apm32f10x_int.c
  group Board
    ../../../../../../Boards/: Board.c
target APM32F107 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F107VC Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.0
  cpu: as above
  output: ADC_ContinuousConversion
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F107xC,APM32F107_MINI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
