# Keil uVision project ETH_FreeRTOS_TcpServer.uvprojx, settings and files
target APM32F107 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F107VC Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ETH_FreeRTOS_TcpServer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F107_MINI,APM32F107xC
  c include: ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include;..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32F107_EVAL\inc;..\..\Include;..\..\..\ETH_FreeRTOS_TcpServer;..\..\..\..\..\..\Middlewares\LwIP\src\include;..\..\..\..\..\..\Middlewares\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\LwIP\src\include\netif;..\..\..\..\..\..\Libraries\APM32F10x_ETH_Driver\inc;..\..\..\..\..\..\Libraries\APM32F10x_ETH_Driver\src;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f10x.c
    ./: startup_apm32f107xc.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_smc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group APM32F10x_ETH_Driver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_eth.c
  group Boards
    ../../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c board_DP83848.c ethernetif.c apm32f10x_int.c sys_arch.c tcp_server_test.c
  group lwip
    ../../../../../../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../Middlewares/LwIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../Middlewares/LwIP/src/netif/: etharp.c
  group FreeRTOS
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
