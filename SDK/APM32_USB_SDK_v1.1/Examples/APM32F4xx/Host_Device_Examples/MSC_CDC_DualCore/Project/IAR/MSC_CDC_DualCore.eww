<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSC_CDC_DualCore.ewp</path>
    </project>
    <batchBuild />
</workspace>
