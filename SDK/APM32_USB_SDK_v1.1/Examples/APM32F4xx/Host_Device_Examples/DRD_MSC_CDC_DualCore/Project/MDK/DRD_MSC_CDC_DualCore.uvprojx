# Keil uVision project DRD_MSC_CDC_DualCore.uvprojx, settings and files
target APM32F407_HS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DRD_MSC_CDC_DualCore
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F40X,APM32F407_EVAL
  c include: ..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32F407_EVAL\inc;..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Host\Core\Inc;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\..\..\..\..\Middlewares\Fat_Fs\source;..\..\Include;..\..\Fat_Fs;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CDC\Inc;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Host\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F407_EVAL/src/: bsp_delay.c
  group App/User
    ../../Source/: main.c apm32f4xx_int.c user_control.c
  group App/User/USB_Device/App
    ../../Source/: usbd_cdc_vcp.c usbd_descriptor.c usb_device_user.c
  group App/User/USB_HOST/App
    ../../Source/: usb_host_user.c
  group App/User/USB/Config
    ../../Source/: usbh_board.c usbd_board.c
  group App/User/FATFS/App
    ../../Source/: fatfs.c
    ../../fat_fs/: diskio.c
  group Libraries/CMSIS
    ./: startup_apm32f40x.s
    ../../Source/: system_apm32f4xx.c
  group Libraries/APM32F4xx_Std_Driver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_gpio.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_misc.c apm32f4xx_rcm.c apm32f4xx_syscfg.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_host.c apm32f4xx_usb_device.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Fat_Fs/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/USB_Host_Library
    ../../../../../../Middlewares/APM32_USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Host_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Host/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/CDC/Src/: usbd_cdc.c
