<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DRD_MSC_CDC_DualCore.ewp</path>
    </project>
    <batchBuild />
</workspace>
