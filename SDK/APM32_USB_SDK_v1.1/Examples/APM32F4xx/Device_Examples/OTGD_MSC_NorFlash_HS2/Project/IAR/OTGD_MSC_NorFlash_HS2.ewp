# IAR project OTGD_MSC_NorFlash_HS2.ewp, settings and files
configuration APM32F407_HS2 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F407IG Geehy APM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F40X; APM32F407_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32F407_EVAL\Inc; ..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\MSC\Inc; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc; ..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGD_MSC_NorFlash_HS2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: APM32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F407_EVAL/src/: bsp_delay.c bsp_w25qxx.c
  group App/User
    ../../Source/: apm32f4xx_int.c main.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_memory.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group CMSIS
    ./: startup_apm32f40x.s
    ../../Source/: system_apm32f4xx.c
  group Libraries/APM32F40x_Std_Driver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
