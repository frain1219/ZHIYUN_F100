<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTGD_MSC_SDCard_HS2.ewp</path>
    </project>
    <batchBuild />
</workspace>
