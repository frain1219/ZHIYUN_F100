# Keil uVision project OTGD_MSC_SDCard_HS2.uvprojx, settings and files
target APM32F407_HS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTGD_MSC_SDCard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F40X,APM32F407_EVAL
  c include: ..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32F407_EVAL\Inc;..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F407_EVAL/src/: bsp_delay.c bsp_sdcard.c
  group App/User
    ../../Source/: main.c apm32f4xx_int.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_memory.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ./: startup_apm32f40x.s
    ../../Source/: system_apm32f4xx.c
  group Libraries/APM32F4xx_Std_Driver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_gpio.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_misc.c apm32f4xx_rcm.c apm32f4xx_syscfg.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_sdio.c apm32f4xx_dma.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
