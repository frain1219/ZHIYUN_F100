<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTGD_Composite_HID_MSC.ewp</path>
    </project>
    <batchBuild />
</workspace>
