<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTGD_MSC_HS_IN_FS.ewp</path>
    </project>
    <batchBuild />
</workspace>
