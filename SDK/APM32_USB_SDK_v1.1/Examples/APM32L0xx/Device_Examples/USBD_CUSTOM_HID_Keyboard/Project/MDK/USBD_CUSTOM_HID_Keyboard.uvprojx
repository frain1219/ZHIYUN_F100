# Keil uVision project USBD_CUSTOM_HID_Keyboard.uvprojx, settings and files
target APM32L072 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32L072VZ Geehy
  pack: Geehy.APM32L0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USBD_CUSTOM_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USB_DEVICE,APM32L072_MINI
  c include: ..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32L072_MINI\inc;..\..\..\..\..\..\Libraries\APM32L0xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32L0xx\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CustomHID\Inc;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32L072_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: main.c apm32l0xx_int.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_custom_hid_if.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ./: startup_apm32l072.s
    ../../Source/: system_apm32l0xx.c
  group Libraries/APM32L0xx_Std_Driver
    ../../../../../../Libraries/APM32L0xx_StdPeriphDriver/src/: apm32l0xx_adc.c apm32l0xx_aes.c apm32l0xx_aes_mode.c apm32l0xx_comp.c apm32l0xx_crc.c apm32l0xx_crs.c apm32l0xx_dac.c apm32l0xx_dbgmcu.c apm32l0xx_dma.c apm32l0xx_eint.c apm32l0xx_fmc.c apm32l0xx_fwl.c apm32l0xx_gpio.c apm32l0xx_i2c.c apm32l0xx_iwdt.c apm32l0xx_lcd.c apm32l0xx_lptmr.c apm32l0xx_lpuart.c apm32l0xx_misc.c apm32l0xx_pmu.c apm32l0xx_rcm.c apm32l0xx_rng.c apm32l0xx_rtc.c apm32l0xx_spi.c apm32l0xx_syscfg.c apm32l0xx_tmr.c apm32l0xx_usart.c apm32l0xx_wwdt.c apm32l0xx_usb.c apm32l0xx_usb_device.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
