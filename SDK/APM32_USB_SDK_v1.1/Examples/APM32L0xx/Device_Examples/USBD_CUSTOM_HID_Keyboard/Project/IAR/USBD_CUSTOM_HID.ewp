# IAR project USBD_CUSTOM_HID.ewp, settings and files
configuration APM32L072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32L072VB Geehy APM32L072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USB_DEVICE; APM32L072_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32L072_MINI\inc; ..\..\..\..\..\..\Libraries\APM32L0xx_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32L0xx\Include; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CustomHID\Inc; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc; ..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32l072xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32L072_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: apm32l0xx_int.c main.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_custom_hid_if.c usbd_descriptor.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group CMSIS
    ./: startup_apm32l072.s
    ../../Source/: system_apm32l0xx.c
  group Libraries/APM32L0xx_Std_Driver
    ../../../../../../Libraries/APM32L0xx_StdPeriphDriver/src/: apm32l0xx_adc.c apm32l0xx_aes.c apm32l0xx_aes_mode.c apm32l0xx_comp.c apm32l0xx_crc.c apm32l0xx_crs.c apm32l0xx_dac.c apm32l0xx_dbgmcu.c apm32l0xx_dma.c apm32l0xx_eint.c apm32l0xx_fmc.c apm32l0xx_fwl.c apm32l0xx_gpio.c apm32l0xx_i2c.c apm32l0xx_iwdt.c apm32l0xx_lcd.c apm32l0xx_lptmr.c apm32l0xx_lpuart.c apm32l0xx_misc.c apm32l0xx_pmu.c apm32l0xx_rcm.c apm32l0xx_rng.c apm32l0xx_rtc.c apm32l0xx_spi.c apm32l0xx_syscfg.c apm32l0xx_tmr.c apm32l0xx_usart.c apm32l0xx_usb.c apm32l0xx_usb_device.c apm32l0xx_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
