# IAR project USBD_CUSTOM_HID_Keyboard.ewp, settings and files
configuration APM32F072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USB_DEVICE; APM32F072_MINI; APM32F072xB
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32F072_MINI\inc; ..\..\Include; ..\..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include; E:\APM32_USB_SDK\Middlewares\APM32_USB_Library\Device\Class\CustomHID\Inc; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID.srec
  ILINK.IlinkOutputFile: USBD_HID.out
  ILINK.IlinkIcfFile: APM32F072xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F072_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: apm32f0xx_int.c main.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_custom_hid_if.c usbd_descriptor.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group CMSIS
    ./: startup_apm32f072.s
    ../../Source/: system_apm32f0xx.c
  group Libraries/APM32F0xx_Std_Driver
    ../../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_usb.c apm32f0xx_usb_device.c apm32f0xx_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
