# Keil uVision project OTGD_CUSTOM_HID_Keyboard.uvprojx, settings and files
target APM32F107 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F107VC Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OTGD_CUSTOM_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F10X_CL,USB_OTG,APM32F107_MINI
  c include: ..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32F107_MINI\inc;..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CustomHID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F107_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: main.c apm32f10x_int.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_custom_hid_if.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ../../Source/: system_apm32f10x.c
    ./: startup_apm32f10x_cl.s
  group Libraries/APM32F10x_Std_Driver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c apm32f10x_usb.c apm32f10x_usb_device.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
