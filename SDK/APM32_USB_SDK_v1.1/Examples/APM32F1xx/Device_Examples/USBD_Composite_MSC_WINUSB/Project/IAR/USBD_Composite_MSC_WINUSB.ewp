# IAR project USBD_Composite_MSC_WINUSB.ewp, settings and files
configuration APM32F103HD (ARM, debug)
  General.OGChipSelectEditMenu: APM32F103ZE Geehy APM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F10X_HD; USB_DEVICE; APM32F103_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32F103_MINI\inc; ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc; ..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Composite_MSC_WINUSB.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F103MD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F103VB Geehy APM32F103VB
  ICCARM.CCDefines: APM32F10X_MD; USB_DEVICE; APM32F103_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32F103_MINI\inc; ..\..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc; ..\..\Include
  ILINK.IlinkIcfFile: apm32f103xB.icf
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../../../../../Boards/Board_APM32F103_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: apm32f10x_int.c main.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_composite.c usbd_composite_memory.c usbd_composite_msc_bot.c usbd_composite_msc_scsi.c usbd_composite_winusb_itf.c usbd_descriptor.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group CMSIS
    ./: startup_apm32f10x_hd.s startup_apm32f10x_md.s
    ../../Source/: system_apm32f10x.c
  group Libraries/APM32F10x_Std_Driver
    ../../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_usb.c apm32f10x_usb_device.c apm32f10x_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
